Commit message: Enough to produce first-pass figures

File: software/models/IRB140/urdf/irb_140_ati_schunk_gelsight_one_finger.urdf (robot description, URDF)
Before this commit: robot IRB140, 11 links, 9 joints
Links:
- link wsg_50_finger_left_link: geometry 
